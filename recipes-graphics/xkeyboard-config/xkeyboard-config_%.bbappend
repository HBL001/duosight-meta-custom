# Build the keyboard-data package for the SDK as well
BBCLASSEXTEND = "native nativesdk"
