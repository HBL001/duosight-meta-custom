FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
# meta-custom kernel append — currently no changes
